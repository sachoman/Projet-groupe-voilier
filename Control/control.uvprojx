# Keil uVision project control.uvprojx, settings and files
target Simule (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_simule
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include;..\Drivers;..\Services;..\Lib_Com_Periph_2022
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Sources
    ./Sources/: control.c
  group Drivers
    ../Drivers/: adc.c adc.h Driver_GPIO.c Driver_GPIO.h girouette.c girouette.h Timer.c Timer.h usart.c usart.h systick.c systick.h
  group Services
    ../Services/: gestion-plateau.c mesure-roulis.c pilotage-servomoteur.c rotation-plateau.c gestion-plateau.h mesure-roulis.h pilotage-servomoteur.h rotation-plateau.h gestionVoile.c gestionVoile.h envoi-donnees.h envoi-donnes.c accelero.c accelero.h batterie.c batterie.h
  group Lib_spi
    ../Lib_Com_Periph_2022/: Lib_Com_Periph_2022.lib MyI2C.h MySPI.h
target Reel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: led_reel
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Drivers;..\Services;..\Lib_Com_Periph_2022;.\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
