# Keil uVision project control.uvprojx, settings and files
target Simule (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_simule
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include;..\..\Drivers;..\Rotation-plateau\Sources;..\Pilotage-servomoteur\Sources;..\Gestion-plateau\Sources;..\Usart-dev\Sources;..\Mesure-roulis\Sources
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Sources
    ./Sources/: control.c gestionVoile.c gestionVoile.h
    ../Gestion-plateau/Sources/: gestion-plateau.c gestion-plateau.h
    ../Pilotage-servomoteur/Sources/: pilotage-servomoteur.c pilotage-servomoteur.h
    ../Rotation-plateau/Sources/: rotation-plateau.c rotation-plateau.h
  group Drivers
    ../../Drivers/: Driver_GPIO.c Timer.c usart.c Driver_GPIO.h usart.h Timer.h girouette.c adc.h adc.c girouette.h
target Reel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: led_reel
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include;..\..\Drivers;.\Sources;..\Rotation-plateau\Sources;..\Usart-dev\Sources;..\Pilotage-servomoteur\Sources;..\Gestion-plateau\Sources;..\Mesure-roulis\Sources
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
